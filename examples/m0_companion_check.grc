options:
  parameters:
    id: m0_companion_check
    title: M0 Companion check
    generate_options: no_gui
    run_options: run
    output_language: python
  states: {}

blocks:
- name: probe_source
  id: robotweax_srt_m0_probe_source
  parameters:
    finish_after_ms: '300'
    wait_inside_work: 'True'
  states: {}
- name: probe_sink
  id: robotweax_srt_m0_probe_sink
  parameters:
    listener: 'False'
    host: 127.0.0.1
    port: '9000'
  states: {}

connections:
- [probe_source, '0', probe_sink, '0']

metadata:
  file_format: 1
