options:
  parameters:
    id: live_sender
    title: Robotweax SRT live sender
    generate_options: no_gui
    run_options: run
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: samp_rate
    waveform: analog.GR_COS_WAVE
    freq: '5000'
    amp: '0.5'
    offset: '0'
    phase: '0'
  states: {}
- name: pace
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: limit
  id: blocks_head
  parameters:
    type: complex
    num_items: int(samp_rate * 3)
  states: {}
- name: sink
  id: robotweax_srt_srt_sink
  parameters:
    sample_format: cf32
    sample_rate_num: samp_rate
    role: caller
    host: 127.0.0.1
    port: '9000'
    continuity: strict_stop
    security: ctr
    passphrase_env: RWSRT_PASSPHRASE
  states: {}

connections:
- [tone, '0', pace, '0']
- [pace, '0', limit, '0']
- [limit, '0', sink, '0']

metadata:
  file_format: 1
