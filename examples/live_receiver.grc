options:
  parameters:
    id: live_receiver
    title: Robotweax SRT live receiver
    generate_options: no_gui
    run_options: run
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: source
  id: robotweax_srt_srt_source
  parameters:
    sample_format: cf32
    sample_rate_num: samp_rate
    role: listener
    bind_address: 127.0.0.1
    port: '9000'
    continuity: strict_stop
    security: ctr
    passphrase_env: RWSRT_PASSPHRASE
  states: {}
- name: status_print
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: out
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [source, '0', out, '0']
- [source, status, status_print, print]

metadata:
  file_format: 1
